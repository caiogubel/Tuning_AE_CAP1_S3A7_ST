# IAR project Tuning_AE_CAP1_S3A7_ST.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FS3A77C Renesas R7FS3A77C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: src; src/synergy_gen; synergy/ssp/inc; synergy/ssp/inc/bsp; synergy/ssp/inc/bsp/cmsis/Include; synergy/ssp/inc/driver/api; synergy/ssp/inc/driver/instances; synergy/ssp/inc/framework/api; synergy/ssp/inc/framework/el; synergy/ssp/inc/framework/instances; synergy/ssp/src/framework/el/tx; synergy/ssp/src/framework/el/ux; synergy_cfg/ssp_cfg/bsp; synergy_cfg/ssp_cfg/driver; synergy_cfg/ssp_cfg/framework; synergy_cfg/ssp_cfg/framework/el
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Tuning_AE_CAP1_S3A7_ST.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
