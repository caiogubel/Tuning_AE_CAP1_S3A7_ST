<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Tuning_AE_CAP1_S3A7_ST.ewp</path>
  </project>
  <batchBuild/>
</workspace>


